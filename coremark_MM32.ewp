# IAR project coremark_MM32.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32L373PS MindMotion MM32L373PS
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __IAR; __MT304; __EX_GPIO; __MM32_MB024; OVERTIME=0; CLOCK=8000000; __USER_RESOURCE; _SYS_RESOURCE_IT; _SYS_RESOURCE_POLLING
  ICCARM.CCIncludePath2: bsp\inc; lib\HAL_lib\inc; lib\startup\inc; User\inc; User\Coremark
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: coremark_MM32.srec
  ILINK.IlinkOutputFile: coremark_MM32.out
  ILINK.IlinkIcfFile: coremark_MM32.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group bsp
    bsp/: bsp.c bsp_adc.c bsp_can.c bsp_comp.c bsp_crs.c bsp_dac.c bsp_i2c.c bsp_key.c bsp_led.c bsp_mco.c bsp_opamp.c bsp_tim.c bsp_uart.c
  group lib
    lib/HAL_lib/: common.c HAL_adc.c HAL_aes.c HAL_bkp.c HAL_can.c HAL_comp.c HAL_crc.c HAL_crs.c HAL_dac.c HAL_dbg.c HAL_div.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_nvic.c HAL_opamp.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_sqrt.c HAL_tim.c HAL_uart.c HAL_uid.c HAL_wwdg.c
  group system
    lib/startup/: startup_mm32.c system_mm32.c
  group users
    User/: core_portme.c
  group users/Coremark
    User/Coremark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c
